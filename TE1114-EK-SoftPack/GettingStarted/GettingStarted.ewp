# IAR project GettingStarted.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1114 NXP LPC1114
  ICCARM.CCDefines: IAR_LPC_1114_SK
  ICCARM.CCIncludePath2: ; board; modules
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GettingStarted.hex
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\LPC1114_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup_M.s main.c readme.txt
  group modules
    modules/: ntc.c temperature.c
