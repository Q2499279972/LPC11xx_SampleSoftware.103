# IAR project systick.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1114 NXP LPC1114
  ICCARM.CCDefines: __DEBUG_RAM
  ICCARM.CCIncludePath2: ..\Common\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: ADC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\common\icf\LPC1114_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG_FLASH
  postbuild: ielftool --checksum __vector_table_0x1c:4,sum32:2;0-0x1B --bin "$EXE_DIR$\$PROJ_FNAME$.out" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkIcfFile: ..\common\icf\LPC1114_Flash.icf
  group (top)
    ../: readme.txt
    ./: systicktest.c
  group Common
    ../Common/src/: clkconfig.c core_cm0.c cstartup_M.s gpio.c system_LPC11xx.c timer16.c timer32.c uart.c
