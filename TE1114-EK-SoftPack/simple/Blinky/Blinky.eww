<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Blinky.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Blinky</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>Blinky</project>
        <configuration>RAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


