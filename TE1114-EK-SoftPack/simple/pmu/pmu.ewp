# IAR project pmu.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1114 NXP LPC1114
  ICCARM.CCDefines: __DEBUG_RAM
  ICCARM.CCIncludePath2: ..\Common\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: ADC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\common\icf\LPC1114_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: pmu.c pmutest.c
    ../: readme.txt
  group Common
    ../Common/src/: clkconfig.c core_cm0.c cstartup_M.s gpio.c system_LPC11xx.c timer16.c timer32.c uart.c
